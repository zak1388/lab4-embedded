# Keil uVision project Lab4.uvprojx, settings and files
target KL28Z (6160000::V6.16::ARMCLANG)
  device: MKL28Z512VLL7 NXP
  pack: NXP.MKL28Z7_DFP.11.0.1
  cpu: IRAM(0x1fff8000,0x020000) IRAM2(0x40100000,0x0800) IROM(0x00000000,0x080000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Lab4.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x20000
  memory RVCT10: RAM 0x40100000 size 0x800
  scatter file: .\RTE\Device\MKL28Z512VLL7\MKL28Z512xxx7_flash.scf
  link misc: --load_addr_map_info --summary_stderr --info summarysizes
  group src
    ./src/: main.c SysTick.c button.c lpit.c TPM_PWM.c triColorLedPWM.c clock.c
  group New Group
    ./inc/: button.h clock.h lpit.h mask.h SysTick.h tpmPwm.h triColorLedPWM.h
software components: CMSIS:CORE 6.1.0, Device:Startup:MKL28Z7_startup 1.0.0
